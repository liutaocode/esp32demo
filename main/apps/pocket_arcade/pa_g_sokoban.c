/* 推箱子 —— 两百关。三个键装四个方向的办法是"转向 + 前进":
   上键逆时针转,下键顺时针转,确定键往箭头方向走一步,双击撤销。 */
#include "pa_game.h"
#include <string.h>

enum { CELL = 18, BOARD_X = 18, BOARD_Y = 8, CLEAR_MS = 1100 };

static const int8_t STEP_X[4] = {1, 0, -1, 0};
static const int8_t STEP_Y[4] = {0, 1, 0, -1};

/* 关卡用字符写:# 墙, . 目标, $ 箱子, * 箱子压在目标上, @ 人, + 人站在目标上。
   每关九列八行,箱子数与目标数必须相等,可解性由主机测试里的求解器逐关验证。
   存成定长字符数组而不是指针表:两百关省下的那张指针表比关卡本身还大。
   前面几关是手写的入门关,后面按推动步数从少到多排,难度是连续的。 */
const char PA_SOK_LEVEL[PA_SOK_LEVELS][PA_SOK_H][PA_SOK_W + 1] = {
    {"#########", "#       #", "#       #", "#  @$ . #",
     "#       #", "#       #", "#       #", "#########"},
    {"#########", "#       #", "# .$ $. #", "#       #",
     "#   @   #", "#   $   #", "#   .   #", "#########"},
    {"#########", "#   .   #", "#       #", "# # $ # #",
     "#   @   #", "# .$ $. #", "#       #", "#########"},
    {"#########", "#  .    #", "#       #", "#  $    #",
     "#  @    #", "#       #", "#  $  . #", "#########"},
    {"#########", "#       #", "#  $  . #", "#   @   #",
     "#  $  . #", "#       #", "#       #", "#########"},
    {"#########", "#       #", "#  ###  #", "#  $  . #",
     "#  @    #", "#  $  . #", "#       #", "#########"},
    {"#########", "#  ...  #", "#       #", "#  $$$  #",
     "#       #", "#   @   #", "#       #", "#########"},
    {"#########", "#       #", "# # $.$ #", "#  .#  .#",
     "# ##@*  #", "# # # $ #", "#       #", "#########"},
    {"#########", "#  @    #", "#  $  $ #", "#    # .#",
     "#    .  #", "# # # $ #", "#      .#", "#########"},
    {"#########", "#+$  .  #", "#$*$    #", "#    #  #",
     "#   ##  #", "# . ##  #", "#       #", "#########"},
    {"#########", "#       #", "# $ . # #", "#  .$## #",
     "# # +   #", "# $ # $ #", "#      .#", "#########"},
    {"#########", "#  .    #", "# **    #", "#  @ #$ #",
     "# #.  $ #", "#   ##  #", "#       #", "#########"},
    {"#########", "#. $    #", "#   # # #", "# .$+   #",
     "#  ##   #", "# #   $ #", "#   .$  #", "#########"},
    {"#########", "#      .#", "#  $    #", "#$  #   #",
     "#+#. #$ #", "#$ # #  #", "#.      #", "#########"},
    {"#########", "#       #", "#   .## #", "#.$     #",
     "#.# #   #", "#$ $# # #", "#@$ .   #", "#########"},
    {"#########", "#       #", "# .     #", "# $   #.#",
     "#    ## #", "# #  *#$#", "#.    $@#", "#########"},
    {"#########", "#       #", "#  # #* #", "#   @  .#",
     "# . $#$ #", "# #   * #", "#       #", "#########"},
    {"#########", "#  .@$  #", "#.##    #", "#  #  # #",
     "#$#   $ #", "#  # .$ #", "#      .#", "#########"},
    {"#########", "#@$ .   #", "#*#  #  #", "# #     #",
     "#  ###  #", "#   $.  #", "#   $.  #", "#########"},
    {"#########", "#       #", "#    #  #", "# $     #",
     "# #     #", "#  #  $.#", "# .$ .@ #", "#########"},
    {"#########", "#       #", "# .$ .$.#", "#    .  #",
     "#   #$# #", "# @$  # #", "#       #", "#########"},
    {"#########", "#  .    #", "# $   # #", "# @#    #",
     "# $     #", "#     #$#", "#    . .#", "#########"},
    {"#########", "# *  . .#", "#      $#", "# @     #",
     "# $# #  #", "# .$ ## #", "#       #", "#########"},
    {"#########", "#       #", "#. . $  #", "# #.$+# #",
     "#  $ $  #", "#  #    #", "#       #", "#########"},
    {"#########", "#.   .  #", "#  $@$  #", "#  # #  #",
     "#  # #$ #", "#       #", "#     . #", "#########"},
    {"#########", "#      .#", "#@*  #  #", "# . #   #",
     "#  $  $ #", "# #     #", "#       #", "#########"},
    {"#########", "#      .#", "#   # #@#", "#      $#",
     "#  # #  #", "#   $   #", "#. $   .#", "#########"},
    {"#########", "#      .#", "# # *#  #", "#     $ #",
     "#  ##  $#", "# #     #", "#  $@ ..#", "#########"},
    {"#########", "# .     #", "# *$ ## #", "#  .    #",
     "# ###$  #", "# #.  $ #", "#     @ #", "#########"},
    {"#########", "#   .   #", "#     $ #", "#   $ ..#",
     "#   # # #", "#  #  $@#", "#       #", "#########"},
    {"#########", "#       #", "# $ #.$ #", "#   #   #",
     "#    #  #", "#+$. #$ #", "#    .  #", "#########"},
    {"#########", "#      .#", "#.#   # #", "#   #  $#",
     "#       #", "#  $ .$ #", "#  @    #", "#########"},
    {"#########", "#    .  #", "#   $ $ #", "#  # #  #",
     "#    *@ #", "# # # * #", "#   .   #", "#########"},
    {"#########", "#       #", "#  #   .#", "# @$  * #",
     "#     # #", "# #  $  #", "#      .#", "#########"},
    {"#########", "# * .   #", "#   #  .#", "#   ##$ #",
     "#  $    #", "#  @ #  #", "#       #", "#########"},
    {"#########", "#  .    #", "#@$  $  #", "# #.#   #",
     "#  ##   #", "#   $ # #", "#     . #", "#########"},
    {"#########", "# .$    #", "#.## @  #", "# ###$  #",
     "# $     #", "#      .#", "#       #", "#########"},
    {"#########", "#      .#", "# $  $  #", "# # #   #",
     "#. #@#  #", "# # $   #", "#  .    #", "#########"},
    {"#########", "#   $ . #", "# $ # # #", "#       #",
     "# @$ .# #", "#.      #", "#       #", "#########"},
    {"#########", "#      .#", "#     # #", "# $@$   #",
     "#  .#   #", "# #$ ## #", "#  .    #", "#########"},
    {"#########", "#       #", "# * ##$.#", "#   #   #",
     "# #$    #", "#    #$ #", "#   ..@ #", "#########"},
    {"#########", "#       #", "#.  . $ #", "#$#  @  #",
     "# .  $# #", "#* #    #", "#       #", "#########"},
    {"#########", "#     . #", "# $ $ * #", "#       #",
     "#.##.## #", "#  $@   #", "#       #", "#########"},
    {"#########", "#       #", "#   #   #", "#   $@  #",
     "#   #$  #", "#  # . .#", "#  . $  #", "#########"},
    {"#########", "#       #", "# $ .## #", "#   $+$ #",
     "# #   # #", "#   $.  #", "#.      #", "#########"},
    {"#########", "#       #", "#  ## $ #", "#.   # .#",
     "#  $@$  #", "#   *##.#", "#       #", "#########"},
    {"#########", "#      .#", "# #   $@#", "#  .  $ #",
     "#   . # #", "# $  ## #", "#       #", "#########"},
    {"#########", "#     @ #", "#.   $$ #", "# $    .#",
     "#. $.## #", "#   #   #", "#       #", "#########"},
    {"#########", "#  .. $@#", "#  # ##*#", "# #     #",
     "#  $$   #", "#       #", "#   .   #", "#########"},
    {"#########", "#   .   #", "#.@#$   #", "# $   # #",
     "#   $#  #", "# #. #  #", "#       #", "#########"},
    {"#########", "#.   * .#", "#   *@# #", "# $  ## #",
     "#   ##  #", "# #    $#", "#       #", "#########"},
    {"#########", "# . .   #", "# # $ # #", "# ##    #",
     "# @*  # #", "# $#    #", "#       #", "#########"},
    {"#########", "#  .    #", "#    $. #", "#  #$ . #",
     "# $     #", "# @ ##  #", "#       #", "#########"},
    {"#########", "#    .  #", "#. $ #* #", "# .   # #",
     "# #$@$  #", "#    ## #", "#       #", "#########"},
    {"#########", "#      .#", "#$#     #", "#.# # * #",
     "#   .#@ #", "#  $ $  #", "#       #", "#########"},
    {"#########", "#    .  #", "# $ .   #", "# # $## #",
     "#  $@#  #", "# * #   #", "#.      #", "#########"},
    {"#########", "# .     #", "#   #   #", "# $   # #",
     "#.  #   #", "#   $@  #", "#.  $   #", "#########"},
    {"#########", "#       #", "#.#   @ #", "#   # $ #",
     "#  $    #", "#*#    .#", "#       #", "#########"},
    {"#########", "# .     #", "#.    # #", "#  $# # #",
     "#   +$  #", "#$ ###  #", "# . $   #", "#########"},
    {"#########", "#    .  #", "#.##  $ #", "#     @ #",
     "#   $ $ #", "# # #   #", "#     . #", "#########"},
    {"#########", "# .     #", "# #  #  #", "#    #. #",
     "# # $@$ #", "#    $  #", "#  .    #", "#########"},
    {"#########", "#       #", "# #$  $ #", "#@#.    #",
     "#$ # .  #", "# # $  .#", "#.      #", "#########"},
    {"#########", "#  .    #", "# .$  $@#", "#    ## #",
     "#  #    #", "#     $ #", "#  .    #", "#########"},
    {"#########", "#+ $    #", "#$ #    #", "#.## #  #",
     "#       #", "#*#  #$ #", "#      .#", "#########"},
    {"#########", "#      .#", "# * $## #", "# #   #$#",
     "#   .  @#", "#  .# $ #", "#       #", "#########"},
    {"#########", "#.      #", "# .     #", "# $  $  #",
     "#  $#@# #", "# #. ## #", "#     $.#", "#########"},
    {"#########", "#       #", "#. @*   #", "#  #    #",
     "# ##  # #", "#   $$  #", "#  .    #", "#########"},
    {"#########", "#      .#", "#    # @#", "#     $$#",
     "# $ #. .#", "#  # #$ #", "#  .    #", "#########"},
    {"#########", "# . @$ .#", "#  $  # #", "#       #",
     "#.    $ #", "# # #   #", "#       #", "#########"},
    {"#########", "#    .  #", "#.      #", "#.$##$# #",
     "# +$    #", "#  $##  #", "#       #", "#########"},
    {"#########", "#     *@#", "#.#  # $#", "# $ # # #",
     "#     # #", "#  $    #", "#    . .#", "#########"},
    {"#########", "# .     #", "#   #   #", "#. $@#  #",
     "# $ # $ #", "#  . *  #", "#       #", "#########"},
    {"#########", "#       #", "#   $@  #", "#  . $  #",
     "#.# .## #", "#    $  #", "#       #", "#########"},
    {"#########", "# $.   .#", "# $   + #", "#.   #$ #",
     "#    #  #", "#  #  $ #", "#       #", "#########"},
    {"#########", "# $  .  #", "#  #   $#", "# #     #",
     "#  #   .#", "#  $@ $.#", "#  .    #", "#########"},
    {"#########", "#       #", "#. #    #", "# $ ##  #",
     "# # ##. #", "#  $    #", "#@$  .  #", "#########"},
    {"#########", "#@$  . .#", "#$####  #", "#       #",
     "#. #  $ #", "# *     #", "#       #", "#########"},
    {"#########", "#       #", "# . $#  #", "# .$@   #",
     "# $ #$# #", "#.    . #", "#       #", "#########"},
    {"#########", "#  .@   #", "# # $#  #", "#   .## #",
     "#  $    #", "#  $  $ #", "#.     .#", "#########"},
    {"#########", "#       #", "#  $#   #", "#  . $. #",
     "# #@    #", "# #$#$#.#", "#.      #", "#########"},
    {"#########", "#      .#", "#  ##   #", "#     $+#",
     "# $     #", "#  .#$# #", "#       #", "#########"},
    {"#########", "#       #", "#  .#   #", "# $ .   #",
     "# @ #.$ #", "# $ # $ #", "#      .#", "#########"},
    {"#########", "# .    .#", "#      $#", "# $  $ @#",
     "#      .#", "# #$# # #", "#.      #", "#########"},
    {"#########", "#  ..   #", "# #     #", "#.$ $$ .#",
     "#    @# #", "# # $#  #", "#       #", "#########"},
    {"#########", "#   .   #", "#.  #   #", "#    $  #",
     "#   #@# #", "#  $ $. #", "#    $. #", "#########"},
    {"#########", "# $  .  #", "#   ##  #", "#.$     #",
     "#.   ## #", "# .$ $  #", "#  @    #", "#########"},
    {"#########", "# .$. $@#", "#       #", "#.  # $ #",
     "#    *  #", "#  #  # #", "#       #", "#########"},
    {"#########", "#       #", "#     *@#", "#  #  # #",
     "#       #", "#.#$##$ #", "#.      #", "#########"},
    {"#########", "# @    .#", "# *$.#  #", "#  #  # #",
     "#   #$* #", "#       #", "#       #", "#########"},
    {"#########", "#   @*. #", "#    #  #", "# # # # #",
     "#   $   #", "#   $.$ #", "#  .    #", "#########"},
    {"#########", "#    .$+#", "#   ##*$#", "#  ##   #",
     "# # $   #", "#      .#", "#       #", "#########"},
    {"#########", "#  .    #", "# #  ## #", "#   ## .#",
     "#   $ # #", "#     *$#", "#     *@#", "#########"},
    {"#########", "#.  .   #", "#@# $   #", "#$  #   #",
     "#  $  # #", "#   $   #", "#.  .   #", "#########"},
    {"#########", "# .     #", "# # $ . #", "#       #",
     "#  #  # #", "#  #*$$ #", "#   +   #", "#########"},
    {"#########", "#     . #", "# ## $  #", "#    $  #",
     "#  # $  #", "# $ # . #", "#.@ .   #", "#########"},
    {"#########", "#.  $   #", "#   #$  #", "#  #  $ #",
     "#    .@ #", "# #.  * #", "#       #", "#########"},
    {"#########", "#    .  #", "# #  $ $#", "# #   # #",
     "#  $ #  #", "# $ .# .#", "# @  .  #", "#########"},
    {"#########", "#       #", "# @# #  #", "# $   ..#",
     "#  ##   #", "# . $$# #", "#       #", "#########"},
    {"#########", "#      .#", "#@$  $#*#", "#  #    #",
     "# # #   #", "#  $..  #", "#       #", "#########"},
    {"#########", "#   .   #", "#   #$  #", "# #   @ #",
     "#  ## $ #", "# # #   #", "# .. $  #", "#########"},
    {"#########", "# .   . #", "#  $.## #", "#  #$ # #",
     "# $     #", "#       #", "# @$ .  #", "#########"},
    {"#########", "#.      #", "# ## $  #", "# .  #  #",
     "#     $ #", "# * #   #", "# @     #", "#########"},
    {"#########", "#.$     #", "#  # # .#", "#.##    #",
     "#       #", "# $$# $ #", "# .   @ #", "#########"},
    {"#########", "#   .   #", "# ##  $ #", "# @$ ## #",
     "# $# #  #", "#     . #", "# .     #", "#########"},
    {"#########", "#       #", "# @# .  #", "# $ #   #",
     "#   #  .#", "#  #  $$#", "#   .   #", "#########"},
    {"#########", "# .     #", "# #.$   #", "#  #@$  #",
     "#.# #   #", "#   $ # #", "#       #", "#########"},
    {"#########", "#       #", "#.    # #", "# # #   #",
     "#.   $@ #", "# $ $#  #", "#    .  #", "#########"},
    {"#########", "# .     #", "#   #   #", "#$# $@  #",
     "#.    $ #", "#  #    #", "#  .    #", "#########"},
    {"#########", "#       #", "#.#$ $  #", "#       #",
     "# $+    #", "#.##    #", "#       #", "#########"},
    {"#########", "#       #", "#   $. .#", "#   ### #",
     "#       #", "# #$#$# #", "#  @  . #", "#########"},
    {"#########", "#   .   #", "# $  ## #", "# . $@# #",
     "#   #$  #", "# #   . #", "#  .  $ #", "#########"},
    {"#########", "#       #", "# ##@$  #", "#. ### .#",
     "# .     #", "# $ *$# #", "#       #", "#########"},
    {"#########", "#    .  #", "#  #  # #", "# $  #@ #",
     "# # $#$ #", "# #   . #", "# .     #", "#########"},
    {"#########", "#       #", "# @*  $ #", "#  #. # #",
     "# $ #.$ #", "#     #.#", "#       #", "#########"},
    {"#########", "#       #", "#   @*  #", "# # #   #",
     "#  $ # .#", "# $  .# #", "#       #", "#########"},
    {"#########", "#  .  . #", "# .$  # #", "#   $@$ #",
     "#  #    #", "# #  $  #", "#      .#", "#########"},
    {"#########", "#  .   .#", "# #  #  #", "#   .   #",
     "# #   $ #", "#  $ $@ #", "#       #", "#########"},
    {"#########", "#       #", "# #   #.#", "#       #",
     "#.## $# #", "# *# $@ #", "#       #", "#########"},
    {"#########", "# @     #", "# $  #$ #", "#. .#   #",
     "#  #  # #", "#  $ #* #", "#      .#", "#########"},
    {"#########", "#   ..  #", "#$ @$ # #", "#       #",
     "#  $##  #", "#       #", "#.   .$ #", "#########"},
    {"#########", "#   @.  #", "#   $   #", "# $ .   #",
     "# #     #", "# # $$#.#", "#     . #", "#########"},
    {"#########", "#       #", "#   $   #", "# $ . . #",
     "#  $ ## #", "#   $ # #", "#.  @.  #", "#########"},
    {"#########", "#       #", "#  $ #  #", "#. ##   #",
     "#     $@#", "#   $ # #", "#.    . #", "#########"},
    {"#########", "#  .  . #", "# #$# # #", "#    $@ #",
     "# ##  # #", "#     $ #", "#..$    #", "#########"},
    {"#########", "#     . #", "# # $ $ #", "# $ .#  #",
     "#  #  @ #", "#   # $.#", "#      .#", "#########"},
    {"#########", "#..     #", "# $  .  #", "#   $   #",
     "#$##@ # #", "#.    $ #", "#       #", "#########"},
    {"#########", "#@$..   #", "#$#  #$ #", "#       #",
     "# #  $  #", "# #    .#", "#.      #", "#########"},
    {"#########", "#   * ..#", "#       #", "# $@$ # #",
     "#     # #", "#  #    #", "#       #", "#########"},
    {"#########", "#      +#", "#  # $.$#", "#   # # #",
     "#$ # #  #", "# # $.  #", "#.      #", "#########"},
    {"#########", "#       #", "#. #.   #", "# # #   #",
     "#   # $ #", "# $ ## $#", "#     *+#", "#########"},
    {"#########", "# .@    #", "#  $   .#", "#$   # .#",
     "#. #$#  #", "#     $ #", "#       #", "#########"},
    {"#########", "#.     @#", "# #$  $$#", "# .   # #",
     "#  #    #", "# # #  .#", "#       #", "#########"},
    {"#########", "#  $@ . #", "#   $   #", "# #   # #",
     "#  *  # #", "# $ .   #", "#     . #", "#########"},
    {"#########", "#       #", "#.    # #", "# ##$ # #",
     "# . @   #", "# #$ #$ #", "# .     #", "#########"},
    {"#########", "#.     .#", "#  #  # #", "#$ # .  #",
     "#       #", "# $ . $$#", "# @     #", "#########"},
    {"#########", "# .     #", "# $# #$ #", "# .     #",
     "# #$.   #", "# $@  # #", "#    .  #", "#########"},
    {"#########", "#  . .  #", "#  #$#  #", "# $#+$  #",
     "#   #   #", "# # $ # #", "# .     #", "#########"},
    {"#########", "#.      #", "#   #$. #", "#  #    #",
     "#    #. #", "# $   $@#", "#   $ . #", "#########"},
    {"#########", "#       #", "# # ##$ #", "#  . $@ #",
     "#   $#  #", "# # .*# #", "#   .   #", "#########"},
    {"#########", "#..  $  #", "#  *$#  #", "#    ## #",
     "#       #", "# $#.   #", "# @     #", "#########"},
    {"#########", "# .$ @  #", "#    $  #", "# #     #",
     "#  #$#  #", "#       #", "#.   .  #", "#########"},
    {"#########", "#     . #", "# $  @# #", "# .  *  #",
     "#  $# # #", "#.# $ # #", "#       #", "#########"},
    {"#########", "#     ..#", "# #*$#  #", "#.   #  #",
     "#       #", "#   $  $#", "#   @   #", "#########"},
    {"#########", "# .     #", "#. #    #", "# ### $ #",
     "# . $ @ #", "# $ #   #", "#       #", "#########"},
    {"#########", "#       #", "#  $@ $ #", "#       #",
     "#  # #* #", "#   #   #", "#  ..   #", "#########"},
    {"#########", "#    .$ #", "#.    $ #", "#  .  # #",
     "#  ## # #", "# $ $ # #", "# @   . #", "#########"},
    {"#########", "#       #", "#       #", "# $$  #.#",
     "#  @#   #", "#   #.$ #", "#     . #", "#########"},
    {"#########", "#      .#", "#   $  .#", "#       #",
     "# ## ## #", "#  #* #$#", "#.    $@#", "#########"},
    {"#########", "#       #", "#   $ # #", "# # $.  #",
     "#.   $@ #", "# # * # #", "#.      #", "#########"},
    {"#########", "# .   $ #", "# #     #", "# @#.$# #",
     "# $ $ # #", "#  .  # #", "#.      #", "#########"},
    {"#########", "#      .#", "# $     #", "#.  # #.#",
     "#  $@   #", "#   ##$ #", "#       #", "#########"},
    {"#########", "#.      #", "# .$$ # #", "# #  #  #",
     "#  $    #", "# #@$.  #", "#      .#", "#########"},
    {"#########", "#       #", "#.*#    #", "#   # $ #",
     "# $ # @ #", "#   # $ #", "# .    .#", "#########"},
    {"#########", "#     @ #", "# $# $$.#", "#   ##  #",
     "#    .  #", "#.# $#  #", "#     . #", "#########"},
    {"#########", "#       #", "#    $@ #", "# $#*#  #",
     "#     # #", "# #.$ # #", "#..     #", "#########"},
    {"#########", "#.      #", "#  $ ##.#", "#    .#$#",
     "#      @#", "# $  $  #", "#      .#", "#########"},
    {"#########", "#       #", "#     . #", "#   #.# #",
     "#  ##.$ #", "# $$  # #", "# @     #", "#########"},
    {"#########", "#       #", "#     $ #", "# #@ #  #",
     "#  $    #", "# $ #*# #", "#.    ..#", "#########"},
    {"#########", "#..  *  #", "# #     #", "#  #    #",
     "#   #   #", "#$# #$# #", "#     $+#", "#########"},
    {"#########", "#       #", "#$$#. @ #", "# .#  $ #",
     "# #     #", "#. $ #  #", "#      .#", "#########"},
    {"#########", "#       #", "# $     #", "#. $ #  #",
     "# #  # .#", "#    $* #", "#    .@ #", "#########"},
    {"#########", "#       #", "# $ $$  #", "#  $@ # #",
     "#...#   #", "# # #   #", "#   .   #", "#########"},
    {"#########", "#       #", "#  *  # #", "# .#$@  #",
     "#  # $  #", "#. #    #", "#       #", "#########"},
    {"#########", "#       #", "#  $@$  #", "# ###  .#",
     "#     # #", "#   $  .#", "#     . #", "#########"},
    {"#########", "#       #", "#$$     #", "#  $    #",
     "# . @## #", "# .#$#  #", "#.     .#", "#########"},
    {"#########", "#       #", "# $ # $.#", "#@$  ## #",
     "# # ..  #", "#     $ #", "#  .    #", "#########"},
    {"#########", "#       #", "#  $   .#", "#   #*#.#",
     "#  #    #", "#    $  #", "#@$    .#", "#########"},
    {"#########", "#  .    #", "#  .$   #", "# .  #$ #",
     "# .#  @ #", "# $ $#  #", "#       #", "#########"},
    {"#########", "#     . #", "# $ # # #", "# @ #   #",
     "# # $ # #", "# #.$ $ #", "# . .   #", "#########"},
    {"#########", "#.      #", "# #$    #", "# #@$ $ #",
     "#  ##   #", "#  ##   #", "#  . .  #", "#########"},
    {"#########", "#.   $ .#", "#       #", "#     # #",
     "#  #$ # #", "# $.    #", "#.   $@ #", "#########"},
    {"#########", "#       #", "#    #  #", "#  ###$ #",
     "# # .@  #", "#  # $$ #", "#..     #", "#########"},
    {"#########", "# @.  . #", "#.$# $$ #", "#. #    #",
     "#   ### #", "#  $  # #", "#       #", "#########"},
    {"#########", "#..     #", "# #     #", "# @$ #$ #",
     "# .#    #", "#   $ # #", "#       #", "#########"},
    {"#########", "# .   @ #", "# . $ $ #", "# $ #   #",
     "#  # #  #", "#    $  #", "#   .  .#", "#########"},
    {"#########", "#  .    #", "#. # $  #", "# $ $@$ #",
     "#   #   #", "#  #  #.#", "# .     #", "#########"},
    {"#########", "#    .  #", "#     #.#", "# $     #",
     "# @$  # #", "# ##  $ #", "#.      #", "#########"},
    {"#########", "#       #", "#. $$   #", "#  #@#  #",
     "#   $  .#", "# #$  # #", "#..     #", "#########"},
    {"#########", "#     ..#", "#      .#", "# $## $ #",
     "# @ $   #", "# #     #", "#       #", "#########"},
    {"#########", "#       #", "#  $ $  #", "# #$  @ #",
     "# ..  $ #", "# ##    #", "#  .  . #", "#########"},
    {"#########", "# .     #", "#     # #", "#       #",
     "# @* $$ #", "# ## $  #", "# . .   #", "#########"},
    {"#########", "#  .  ..#", "#    $  #", "# $ $@$ #",
     "#   #   #", "# # # # #", "#      .#", "#########"},
    {"#########", "#    @ .#", "#    $# #", "#  # .$.#",
     "# $  .# #", "# $  #  #", "#       #", "#########"},
    {"#########", "#       #", "#       #", "#$ $+#  #",
     "#  #    #", "#.. # $ #", "#.  $   #", "#########"},
    {"#########", "#  @  . #", "# $$ $$ #", "#     . #",
     "# # .#  #", "#   #  .#", "#       #", "#########"},
    {"#########", "#       #", "# $# #  #", "# @#$#  #",
     "# $ .   #", "#   # #.#", "#    .  #", "#########"},
    {"#########", "# ..    #", "#  #  $ #", "#     # #",
     "#@$   # #", "#     $ #", "#.   .$ #", "#########"},
    {"#########", "#  ..   #", "# $     #", "# ##  $ #",
     "#    $@ #", "#   $ # #", "#.    . #", "#########"},
    {"#########", "#      .#", "# $   # #", "#@$  #  #",
     "# #$ .  #", "# .   $ #", "#   .   #", "#########"},
    {"#########", "#       #", "# $ #.$ #", "# # # # #",
     "#  $@#  #", "# $ #   #", "#.  ..  #", "#########"},
    {"#########", "#  $ . .#", "# #   # #", "#      .#",
     "#  $ #  #", "# #$.#$ #", "#     @ #", "#########"},
    {"#########", "#    .  #", "# $#  # #", "# @$ #*.#",
     "# $#  # #", "#   .   #", "#       #", "#########"},
    {"#########", "#     ..#", "#   $ # #", "# ## .  #",
     "#     $ #", "# $ $ @.#", "#       #", "#########"},
    {"#########", "#.. .   #", "#  .$@  #", "#   $   #",
     "# ##  # #", "#$  # $ #", "#       #", "#########"},
    {"#########", "#       #", "# # #   #", "# # @ $ #",
     "#   $   #", "#.    $ #", "# ..    #", "#########"},
    {"#########", "#     . #", "# $ ##  #", "# # $@#.#",
     "#       #", "#.  $ $ #", "# .     #", "#########"},
    {"#########", "#       #", "#@$   # #", "#  # #. #",
     "#   .  .#", "# $ $ $ #", "#      .#", "#########"},
    {"#########", "#       #", "# #     #", "#   $ # #",
     "# $ @#  #", "# $ # # #", "# * .. .#", "#########"},
    {"#########", "#    .. #", "# $# .$ #", "#   $#  #",
     "#  $@#  #", "#  ## # #", "#      .#", "#########"},
    {"#########", "# .     #", "# $ $   #", "# $ #   #",
     "# # # # #", "# # @$ .#", "#     ..#", "#########"},
};

static void load_level(pa_run_t *run, unsigned level)
{
    pa_sokoban_t *s = &run->u.sokoban;
    memset(s->cell, 0, sizeof(s->cell));
    s->moves = 0;
    s->undos = 0;
    s->dir = 0;
    for (unsigned y = 0; y < PA_SOK_H; y++)
        for (unsigned x = 0; x < PA_SOK_W; x++) {
            char c = PA_SOK_LEVEL[level][y][x];
            uint8_t bits = 0;
            if (c == '#') bits = PA_SOK_WALL;
            if (c == '.' || c == '*' || c == '+') bits |= PA_SOK_GOAL;
            if (c == '$' || c == '*') bits |= PA_SOK_BOX;
            if (c == '@' || c == '+') { s->px = (uint8_t)x; s->py = (uint8_t)y; }
            s->cell[y][x] = bits;
        }
}

static void reset(pa_run_t *run)
{
    pa_sokoban_t *s = &run->u.sokoban;
    memset(s, 0, sizeof(*s));
    load_level(run, 0);
}

static bool solved(const pa_sokoban_t *s)
{
    for (unsigned y = 0; y < PA_SOK_H; y++)
        for (unsigned x = 0; x < PA_SOK_W; x++)
            if ((s->cell[y][x] & PA_SOK_GOAL) && !(s->cell[y][x] & PA_SOK_BOX))
                return false;
    return true;
}

static void advance(pa_run_t *run)
{
    pa_sokoban_t *s = &run->u.sokoban;
    run->score += 100 + (s->moves < 60U ? (60 - s->moves) * 2 : 0);
    s->cleared++;
    s->total_moves = (uint16_t)(s->total_moves + s->moves);
    s->clear_ms = CLEAR_MS;
}

static void walk(pa_run_t *run)
{
    pa_sokoban_t *s = &run->u.sokoban;
    int nx = s->px + STEP_X[s->dir], ny = s->py + STEP_Y[s->dir];
    if (nx < 0 || ny < 0 || nx >= PA_SOK_W || ny >= PA_SOK_H) return;
    if (s->cell[ny][nx] & PA_SOK_WALL) return;
    bool pushed = false;
    if (s->cell[ny][nx] & PA_SOK_BOX) {
        int bx = nx + STEP_X[s->dir], by = ny + STEP_Y[s->dir];
        if (bx < 0 || by < 0 || bx >= PA_SOK_W || by >= PA_SOK_H) return;
        if (s->cell[by][bx] & (PA_SOK_WALL | PA_SOK_BOX)) return;
        s->cell[ny][nx] = (uint8_t)(s->cell[ny][nx] & ~PA_SOK_BOX);
        s->cell[by][bx] = (uint8_t)(s->cell[by][bx] | PA_SOK_BOX);
        pushed = true;
    }
    s->px = (uint8_t)nx;
    s->py = (uint8_t)ny;
    s->moves++;
    /* 撤销栈满了就丢掉最早的一步,栈顶必须永远是刚走的那一步。 */
    if (s->undos == PA_SOK_UNDO) {
        memmove(s->undo, s->undo + 1, PA_SOK_UNDO - 1);
        s->undos--;
    }
    s->undo[s->undos++] = (uint8_t)(s->dir | (pushed ? 4U : 0U));
    if (solved(s)) advance(run);
}

static void undo(pa_run_t *run)
{
    pa_sokoban_t *s = &run->u.sokoban;
    if (!s->undos || s->clear_ms) return;
    uint8_t record = s->undo[--s->undos];
    uint8_t dir = (uint8_t)(record & 3U);
    int bx = s->px + STEP_X[dir], by = s->py + STEP_Y[dir];
    if (record & 4U) {
        s->cell[by][bx] = (uint8_t)(s->cell[by][bx] & ~PA_SOK_BOX);
        s->cell[s->py][s->px] = (uint8_t)(s->cell[s->py][s->px] | PA_SOK_BOX);
    }
    s->px = (uint8_t)(s->px - STEP_X[dir]);
    s->py = (uint8_t)(s->py - STEP_Y[dir]);
    if (s->moves) s->moves--;
}

static void tick(pa_run_t *run, uint32_t ms)
{
    pa_sokoban_t *s = &run->u.sokoban;
    if (!s->clear_ms) return;
    s->clear_ms = (uint16_t)(s->clear_ms > ms ? s->clear_ms - ms : 0);
    if (s->clear_ms) return;
    if (s->level + 1U >= PA_SOK_LEVELS) {
        run->over = true;
        run->note = "两百关全部通关";
        return;
    }
    s->level++;
    load_level(run, s->level);
}

static void key(pa_run_t *run, pa_key_t pressed)
{
    pa_sokoban_t *s = &run->u.sokoban;
    if (s->clear_ms) return;
    switch (pressed) {
    case PA_KEY_UP:   s->dir = (uint8_t)((s->dir + 3U) % 4U); break;
    case PA_KEY_DOWN: s->dir = (uint8_t)((s->dir + 1U) % 4U); break;
    case PA_KEY_OK:   walk(run); break;
    default:          undo(run); break;
    }
}

static void draw(const pa_run_t *run, pa_scene_t *scene)
{
    const pa_sokoban_t *s = &run->u.sokoban;
    pa_textf(scene, 0, PA_ROW_TOP, PA_VIEW_W, PA_INK, PA_FONT_ZH, PA_CENTER,
             "第 %u 关   走了 %u 步", (unsigned)(s->level + 1U), (unsigned)s->moves);
    pa_frect(scene, BOARD_X - 3, BOARD_Y - 3, PA_SOK_W * CELL + 6, PA_SOK_H * CELL + 6,
             0x3C2C1E, 4);
    for (unsigned y = 0; y < PA_SOK_H; y++)
        for (unsigned x = 0; x < PA_SOK_W; x++) {
            uint8_t bits = s->cell[y][x];
            int cx = BOARD_X + (int)x * CELL, cy = BOARD_Y + (int)y * CELL;
            if (bits & PA_SOK_WALL) {
                pa_frect(scene, cx, cy, CELL, CELL, 0x8A6B4B, 2);
                continue;
            }
            if (bits & PA_SOK_BOX)
                pa_frect(scene, cx + 2, cy + 2, CELL - 4, CELL - 4,
                         (bits & PA_SOK_GOAL) ? PA_GREEN : PA_ORANGE, 3);
            else if (bits & PA_SOK_GOAL)
                pa_frect(scene, cx + 6, cy + 6, CELL - 12, CELL - 12, PA_YELLOW, 3);
        }

    int hx = BOARD_X + (int)s->px * CELL, hy = BOARD_Y + (int)s->py * CELL;
    pa_frect(scene, hx + 3, hy + 3, CELL - 6, CELL - 6, PA_RED, 4);
    /* 小箭头写明"确定"会往哪边走。 */
    pa_frect(scene, hx + 8 + STEP_X[s->dir] * 6, hy + 8 + STEP_Y[s->dir] * 6, 4, 4,
             PA_WHITE, 0);

    if (s->clear_ms)
        pa_text(scene, 0, PA_ROW_BOTTOM, PA_VIEW_W, "这一关完成了",
                PA_GREEN, PA_FONT_ZH, PA_CENTER);
    else
        pa_textf(scene, 0, PA_ROW_BOTTOM, PA_VIEW_W, PA_INK, PA_FONT_ZH, PA_CENTER,
                 "得分 %ld   可撤销 %u 步", run->score, (unsigned)s->undos);
    pa_footer(scene, "上下转向　确定前进　双击撤销");
}

const pa_game_t pa_game_sokoban = {
    .id = 22,
    .name = "推箱子", .genre = "益智",
    .hint = "转向加前进，两百关",
    .rule = {"上键逆时针转，下键顺时针转",
             "确定键往箭头方向走一步",
             "双击确定撤销一步，两百关连打"},
    .keys = "上下转向　确定前进",
    .ok_mode = PA_OK_CLICK,
    .star = {2500, 9000, 20000},
    .reset = reset, .tick = tick, .key = key, .draw = draw,
};
